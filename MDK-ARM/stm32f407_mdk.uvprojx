# Keil uVision project stm32f407_mdk.uvprojx, settings and files
target stm32f407_mdk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/@L.bin ./Objects/@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,RT_USING_LIBC,RT_USING_ARM_LIBC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\RT-Thread\include;..\RT-Thread;..\RT-Thread\sys;..\package\customized\Inc;..\package\platform\inc;..\package\customized\firmware\inc;..\package\customized\source\detect;..\package\customized\source\log;..\package\customized\task\inc;..\package\platform\framework\fifo;..\package\platform\framework\log\inc;..\package\platform\framework\sys_api;..\package\platform\framework\sys_cfg;..\package\platform\framework\tmr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RT-Thread/kernal
    ../RT-Thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RT-Thread/cortex-m4
    ../RT-Thread/cortex-m4/: context_rvds.S cpuport.c
  group package/customized/source/detect
    ../package/customized/source/detect/: key_detect.c multi_button.c
  group package/customized/source/log
    ../package/customized/source/log/: log_output.c
  group package/customized/source/task
    ../package/customized/task/src/: can.c custom.c nad.c platform.c system.c
  group package/customized/firrmware/src
    ../package/customized/firmware/src/: board.c bsp_uart.c dev_uart.c task.c
  group package/platform/framework/fifo
    ../package/platform/framework/fifo/: fifo.c
  group package/platform/framework/sys_api
    ../package/platform/framework/sys_api/: sys_api.c sys_api.h
  group package/platform/framework/sys_cfg
    ../package/platform/framework/sys_cfg/: sys_cfg.c sys_cfg.h
  group package/platform/framework/tmr
    ../package/platform/framework/tmr/: tmr.c
  group package/platform/framework/log/src
    ../package/platform/framework/log/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group package/platform/framework/log/port
    ../package/platform/framework/log/port/: elog_port.c
software components: CMSIS:CORE 5.4.0
